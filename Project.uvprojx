# Keil uVision project Project.uvprojx, settings and files
target Target_1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\Application;.\Arm;.\Drivers;.\StdLib_Drivers;.\Peripheral
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application
    ./Application/: main.c app_led.c app_serial.c
  group Drivers
    ./Drivers/: led_drv.c ws2812b_drv.c key_drv.c
  group Peripheral
    ./Peripheral/: systick.c pwm.c dma.c uart.c timer.c
  group StdLib_Drivers
    ./StdLib_Drivers/: misc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_usart.c
  group Arm
    ./Arm/: core_cm3.c startup_stm32f10x_md.s system_stm32f10x.c stm32f10x_it.c
